# Keil uVision project STM32F1-M8266WIFI.uvprojx, settings and files
target STM32F1_M8266WIFI (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F1-M8266WIFI +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM3,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\USER;..;..\M8266WIFI
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c misc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
  group M8266WIFI
    ../M8266WIFI/: M8266HostIf_STM32xx.c M8266WIFIDrv_STM32F1xx.a M8266WIFI_Ops.c test_m8266wifi.c
  group USER
    ./: main.c system_stm32f10x.c stm32f10x_it.c
  group README
    ../: readme.txt
